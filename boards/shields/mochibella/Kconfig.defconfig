## boards/shields/mochibella/Kconfig.shield
```kconfig
# Copyright (c) 2020 Pete Johanson
# SPDX-License-Identifier: MIT

config SHIELD_MOCHIBELLA
	def_bool $(shields_list_contains,mochibella)
```
